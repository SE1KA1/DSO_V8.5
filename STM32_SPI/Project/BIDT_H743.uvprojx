# Keil uVision project BIDT_H743.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.2
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: BIDT_H743 +hex
  c flags: Optim=7 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: .\Drivers\cmsis-core-master\CMSIS\Driver\Include;.\Drivers\stm32h7xx-hal-driver-master\Inc;.\Drivers\CMSIS;.\Drivers\stm32h7xx-hal-driver-master\Src;.\Drivers\cmsis-device-h7-master\Include;.\Drivers\cmsis-core-master\CMSIS\Core\Include;..\Code\User;..\Code\BSP;..\Code\LVGL;..\Code\LVGL\lvgl;..\Code\LVGL\lvgl\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group CMSIS
    ./Drivers/cmsis-device-h7-master/Source/Templates/: system_stm32h7xx.c
  group HAL_Driver
    ./Drivers/stm32h7xx-hal-driver-master/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_spi.c stm32h7xx_hal_pwr.c stm32h7xx_hal_dma.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_sdram.c stm32h7xx_ll_fmc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_dma2d.c
    ./Drivers/stm32h7xx-hal-driver-master/Inc/: stm32h7xx_hal_dma2d.h
  group BSP
    ../Code/BSP/: gpio.c lcd_ltdc.c spi_master.c lcd_lg4573a.h lcd_lg4573a.c bsp_fmc_sdram.c bsp_fmc_sdram.h bsp_lcd_rgb.c bsp_ui_io_expander.h bsp_ui_io_expander.c
  group User
    ../Code/User/: main.c
    ./Drivers/cmsis-device-h7-master/Source/Templates/arm/: startup_stm32h743xx.s
