# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: telemetry +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx
  c include: ..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\..\LWIP\App;..\..\LWIP\Target;..\..\Middlewares\Third_Party\LwIP\src\include;..\..\Middlewares\Third_Party\LwIP\system;..\..\Drivers\BSP\Components\lan8742;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32-v7.sct
  group User
    ../../User/: main.c FreeRTOSConfig.h
  group App_Delivery
    ../../User/dso/: dso_switch_panel.c dso_sht40.c dso_ina226.c dso_ina226_u44.c dso_module_upload.c dso_watchdog.c module_5ch_stub.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: bsp_dwt.c bsp_led.c bsp_uart_fifo.c bsp_i2c_ui.c bsp_pcal6524.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group FreeRTOS/Source
    ../../FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c event_groups.c stream_buffer.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group LWIP
    ../../LWIP/App/: lwip.c
    ../../LWIP/Target/: ethernetif.c
    ../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../Drivers/BSP/Components/lan8742/: lan8742.c
  group LwIP_Core
    ../../Middlewares/Third_Party/LwIP/src/api/: tcpip.c api_lib.c api_msg.c sockets.c netbuf.c netifapi.c err.c
    ../../Middlewares/Third_Party/LwIP/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c dhcp6.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
