# Keil uVision project project.uvprojx, settings and files
target Flash (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: output +hex
  AfterMake: CopyHex_Flash.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER, STM32H743xx,ARM_MATH_CM7,DSO_PLOTBUF_GUARD_ENABLE=1,MAINTASK_STACK_LOG_INTERVAL_MS=2000
  c include: ..\..\Libraries\CMSIS\DSP\Include;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\ST\STM32H7xx\Include;..\..\Libraries\STM32H7xx_HAL_Driver\Inc;..\..\User\bsp\inc;..\..\User;..\..\User\bsp;..\..\FreeRTOS\include;..\..\FreeRTOS\portable\RVDS\ARM_CM7\r0p1;..\..\emWin;..\..\emWin\Config;..\..\emWin\Include;..\..\User\ui;..\..\LWIP\App;..\..\LWIP\Target;..\..\Middlewares\Third_Party\LwIP\src\include;..\..\Middlewares\Third_Party\LwIP\system;..\..\Drivers\BSP\Components\lan8742;..\..\User\dso\fmc16;..\..\Middlewares\Third_Party\FreeRTOS\Source\CMSIS_RTOS;..\..\Middlewares\Third_Party\mbedtls\include
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\stm32-v7.sct
  link libs: arm_cortexM7lfsp_math.lib
  group User
    ../../User/: main.c includes.h SysInfoTest.c rtos_cpu_stats.c FreeRTOSConfig.h dso_integration.h
  group DSO
    ../../User/dso/: dso_acq.c dso_acq10_stream.c dso_acq_10bit.c dso_acq_common.c dso_acq_hal_stm32h7.c dso_cache_range.c dso_sample_spec.c dso_hs8_lane_cal.c dso_10bit_lane_cal.c dso_10bit_display_sync.c dso_hs8_render.c dso_hs10_render.c dso_lane_merge.c dso_acq8_refresh_policy.c dso_acq8_fault_policy.c dso_acq8_sample_unpack.c dso_acq8_tim_trigger.c dso_acq10_tim_trigger.c dso_acq_8bit.c dso_engine.c dso_engine_cal.c dso_engine_roll.c dso_freq_meter.c dso_freq_meter_math.c dso_freq_meter_hw_tim12.c dso_trigger_source_bridge.c dso_roll_line_builder.c dso_roll_physics.c roll_history_mem.c roll_history_ring.c dso_process.c dso_render_policy.c dso_serial_debug_format.c dso_serial_debug.c dso_testgen.c dso_wavegen.c dso_wavegen_lut.c dso_wavegen_timer_math.c dso_wavegen_dac_pa4.c dso_acquire_control.c dso_record.c dso_timebase.c dso_ui_bridge.c dso_vertical.c dso_vofa_firewater.c cloud_bridge.c dso_switch_panel.c dso_switch_cmd.c dso_fmc_telemetry.c dso_sht40.c dso_ina226.c dso_ina226_u44.c dso_atecc608b.c dso_module_upload.c dso_watchdog.c dso_auth_soft.c dso_b64.c dso_devkey.c
    ../../User/dso/fmc16/: fmc16_bus.c fmc16_crc.c fmc16_packet.c fmc16_link.c fmc16_status.c fmc16_command.c fmc16_io.c fmc16_event.c fmc16_integration.c
  group mbedTLS
    ../../Middlewares/Third_Party/mbedtls/library/: bignum.c ecp.c ecp_curves.c ecdsa.c asn1parse.c asn1write.c md.c sha256.c hmac_drbg.c platform.c platform_util.c memory_buffer_alloc.c constant_time.c error.c
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32h7xx_it.c
    ../../User/bsp/src/: debug_uart_lock.c bsp_dwt.c bsp_led.c bsp_key.c bsp_timer.c bsp_beep.c bsp_fmc_io.c bsp_fmc_sdram.c bsp_lcd_rgb.c bsp_uart_fifo.c dma2d_wait.c vram_sentinels.c bsp_tim_pwm.c bsp_ui_io_expander.c bsp_i2c_ui.c bsp_pcal6524.c bsp_cpu_dac.c bsp_i2c_gpio_keil.c bsp_i2c_eeprom_24xx_keil.c
    ../../User/: stm32h7xx_hal_timebase_tim.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/arm/: startup_stm32h743xx.s
  group HAL_Driver
    ../../User/bsp/: stm32h7xx_hal_conf.h
    ../../Libraries/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_gpio.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_ll_fmc.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_sdram.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdma.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c
  group CMSIS
    ../../Libraries/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group SEGGER/HardFault
    ../../User/segger/HardFaultHandlerMDK/: HardFaultHandler.S SEGGER_HardFaultHandler.c
  group FreeRTOS/Source
    ../../FreeRTOS/: list.c queue.c tasks.c timers.c croutine.c event_groups.c stream_buffer.c
    ../../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
  group FreeRTOS/Ports
    ../../FreeRTOS/portable/RVDS/ARM_CM7/r0p1/: port.c portmacro.h
    ../../FreeRTOS/portable/MemMang/: heap_4.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.例程修改记录.txt
  group UI
    ../../User/ui/: MainTask.c ui_screens.c ui_channel_ctrl.c ui_trigger_ui.c ui_freq_format.c ui_nav.c ui_ec_poll_task.c ui_system_setup.c ui_switch_panel.c lcd_rotate_profile.c UI_WaveformCtrl.c dma2d_wave.c roll_history_ui.c
  group emwin
    ../../emWin/Config/: GUIConf.c LCDConf_Lin_Template.c
    ../../emWin/GUI_X/: GUI_X_FreeRTOS.c
    ../../emWin/GUILib/: STemWin_CM7_OS_wc16_ot_ARGB.a
  group LWIP
    ../../LWIP/App/: lwip.c ping.c
    ../../LWIP/Target/: ethernetif.c
    ../../Middlewares/Third_Party/LwIP/system/OS/: sys_arch.c
    ../../Drivers/BSP/Components/lan8742/: lan8742.c
    ../../User/dso/: dso_eth_upload.c
  group LwIP_Core
    ../../Middlewares/Third_Party/LwIP/src/api/: tcpip.c api_lib.c api_msg.c sockets.c netbuf.c netifapi.c err.c
    ../../Middlewares/Third_Party/LwIP/src/core/: init.c def.c dns.c inet_chksum.c ip.c mem.c memp.c netif.c pbuf.c raw.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../../Middlewares/Third_Party/LwIP/src/core/ipv6/: ethip6.c icmp6.c inet6.c ip6.c ip6_addr.c ip6_frag.c mld6.c nd6.c dhcp6.c
    ../../Middlewares/Third_Party/LwIP/src/netif/: ethernet.c
